# Keil uVision project CodeHome.uvprojx, settings and files
target SmartHome (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103R6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CodeHome +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\cmsis;..\STM32F10x_StdPeriph_Driver\inc;..\user\bsp;..\user\HMAC;..\user\MQTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group cmsis
    ../cmsis/: core_cm3.c startup_stm32f10x_ld.s
  group user
    ../user/: stm32f10x_it.c system_stm32f10x.c main.c
  group fwlib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp
    ../user/bsp/: led.c delay.c key.c usart.c dht11.c adc.c lcd.c tu.c Hum.c sun.c Tem.c
    ../user/: ali.c
  group MQTT
    ../user/MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group HMAC
    ../user/HMAC/: utils_hmac.c utils_md5.c utils_sha1.c
  group README
    ../README/: readme.txt
